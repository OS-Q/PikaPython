# Keil uVision project USART.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: USE_STDPERIPH_DRIVER,PIKA_CONFIG_ENABLE
  c include: ..\SYSTEM\delay;..\USER;..\DRIVER\luatos-soc-air32f103\Libraries\AIR32F10xLib\inc;..\DRIVER\luatos-soc-air32f103\Libraries\CMSIS\Include;..\DRIVER\luatos-soc-air32f103\Libraries\CORE;..\DRIVER\luatos-soc-air32f103\Libraries\CMSIS\Lib\ARM;..\pikascript\pikascript-lib/PikaStdDevice;..\pikascript\pikascript-lib/AIR32F1;..\pikascript\pikascript-lib/PikaStdLib;..\pikascript\pikascript-api;..\pikascript\pikascript-core;..\DRIVER\luatos-soc-air32f103\Libraries\AIR32F10xLib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c air32f10x_it.c
    ../DRIVER/luatos-soc-air32f103/Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../DRIVER/luatos-soc-air32f103/Libraries/CORE/: core_cm3.c startup_air32f10x.s
  group FWLib
    ../DRIVER/luatos-soc-air32f103/Libraries/AIR32F10xLib/src/: misc.c air32f10x_usart.c air32f10x_rcc.c air32f10x_gpio.c air32f10x_crc.c air32f10x_dma.c
    ../DRIVER/luatos-soc-air32f103/Libraries/AIR32F10xLib/lib/: air.lib
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c
    ../pikascript/pikascript-lib/AIR32F1/: AIR32F1_UART.c AIR32F1_GPIO.c AIR32F1_PWM.c AIR32F1_SPI.c AIR32F1_Time.c AIR32F1_CAN.c AIR32F1.c AIR32F1_ADC.c AIR32F1_IIC.c AIR32F1_common.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
  group pikascript-api
    ../pikascript/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
  group python
    ../pikascript/: AIR32F1.pyi main.py PikaDebug.pyi PikaObj.pyi PikaStdData.pyi PikaStdDevice.pyi PikaStdLib.pyi PikaStdTask.pyi machine.pyi
