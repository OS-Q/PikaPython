# Keil uVision project pikascript-demo.uvprojx, settings and files
target pikascript-demo (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: pikascript-demo +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,PIKA_CONFIG_ENABLE
  c include: ../Booter;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-lib/PikaStdDevice;..\pikascript\pikascript-lib/STM32F1;..\pikascript\pikascript-lib/PikaStdLib;..\pikascript\pikascript-api;..\pikascript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c PikaStdDevice_BaseDev.c
    ../pikascript/pikascript-lib/STM32F1/: STM32F1_PWM.c STM32F1_ADC.c STM32F1_IIC.c STM32F1_Time.c STM32F1_common.c STM32F1_GPIO.c STM32F1_UART.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_ByteArray.c PikaStdData_FILEIO.c PikaStdData_Tuple.c
  group pikascript-api
    ../pikascript/pikascript-api/: STM32F1_lowLevel-api.c STM32F1_ADC-api.c PikaStdLib-api.c PikaStdDevice_CAN-api.c PikaStdLib_PikaObj-api.c STM32F1_IIC-api.c PikaStdData_Dict-api.c pikaScript.c PikaStdDevice_SPI-api.c STM32F1_PWM-api.c machine_PWM-api.c PikaStdTask_Task-api.c PikaStdDevice_UART-api.c PikaStdDevice-api.c PikaStdDevice_IIC-api.c PikaStdDevice_GPIO-api.c PikaDebug-api.c PikaStdDevice_PWM-api.c machine_GPIO-api.c machine-api.c machine_IIC-api.c PikaStdData_List-api.c PikaStdDevice_Time-api.c PikaDebug_Debuger-api.c PikaStdLib_RangeObj-api.c PikaMain-api.c machine_Time-api.c PikaStdData-api.c STM32F1_GPIO-api.c PikaStdData_ByteArray-api.c PikaStdData_Utils-api.c PikaStdLib_StringObj-api.c machine_ADC-api.c PikaStdData_String-api.c STM32F1_UART-api.c STM32F1-api.c STM32F1_Time-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdDevice_ADC-api.c PikaStdTask-api.c machine_UART-api.c machine_lowLevel-api.c __asset_pikaModules_py_a.c PikaStdData_dict_keys-api.c PikaStdData_FILEIO-api.c PikaStdData_Tuple-api.c PikaStdDevice_BaseDev-api.c
  group Booter
    ../Booter/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c usart.c
    ../: startup_stm32f103xb.s
  group Python
    ../pikascript/: main.py machine.pyi PikaStdLib.pyi STM32F1.pyi
software components: CMSIS:CORE 5.6.0
